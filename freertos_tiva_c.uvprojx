# Keil uVision project freertos_tiva_c.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freertos_tiva_c
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PART_TM4C1294NCPDT
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: main.c tiva_c_led.c application.c tiva_c_uart4.c
  group DriverLibrary
    ./driverlib/rvmdk/: driverlib.lib
software components: RTOS:Config 10.3.1, RTOS:Core 10.3.1, RTOS:Coroutines 10.3.1, RTOS:Event Groups 10.3.1, RTOS:Heap 10.3.1, RTOS:Message Buffer 10.3.1, RTOS:Stream Buffer 10.3.1, RTOS:Timers 10.3.1, CMSIS:CORE 5.5.0, Device:Startup 1.0.0
